# Repository aaydev/trhmsx

## KiCad design hardware/trhmsx/trhmsx.kicad_pcb

Board: 4 copper layers, 150.4 x 120.4 mm, 132 parts (44 on the bottom side), 313 nets.

Parts:
C1, C5, C8, C28, C29, C30, C31, C32: 220uF; CP_Elec_6.3x3
C2, C3, C4, C6, C7, C9, C10, C11, C12, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24: 0.1uF; C_0805_2012Metric
C13, C14: 27pF; C_0805_2012Metric
C25: 2.2uF; C_0805_2012Metric
C26, C27: 4.7uF; C_0805_2012Metric
C33, C34: 3.3uF; C_0805_2012Metric
C35: 10uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED3; LED_0805_2012Metric
F1: Fuse; Fuse_1210_3225Metric
J1: MODULE-12V; PinSocket_1x05_P2.54mm_Vertical
J2: ESP-01; PinSocket_2x04_P2.54mm_Vertical
J3: Barrel_Jack; BarrelJack_Horizontal
J4: MICRO-SD; Conn_uSDcard
J5, J17: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J6: KEYBOARD-USB; TE_6364372-2
J7: KEYBOARD-PS2; TE_5749180-1
J8: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J10: JOY2; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
J11: AudioJack2_Ground; PJ-307
J13: CART2; TE_5530841-5
J14: DH15; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03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
J15: JOY1; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
J16: CART1; TE_5530841-5
J18: S-Video; CUI_MD-40SM
LOGO_MSX: LOGO_MSX
R1, R2: 10K; R_0805_2012Metric
R3, R7: 10; R_0805_2012Metric
R5, R12: 1K; R_0805_2012Metric
R8, R9: 100; R_0805_2012Metric
R10: 22; R_0805_2012Metric
R11: 1M; R_0805_2012Metric
R13, R14: 2.2K; R_0805_2012Metric
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10, RN11, RN13, RN14, RN15, RN16, RN19, RN20, RN21, RN22, RN23, RN36, RN37, RN38, RN39, RN40, RN41, RN42, RN43: 100; R_Array_Convex_4x0603
RN12, RN25, RN26, RN35, RN44: 10K; R_Array_Convex_4x0603
RN17, RN18, RN24: 1K; R_Array_Convex_4x0603
RN27, RN28, RN29, RN30, RN31, RN32, RN33, RN34: 200; R_Array_Convex_4x0603
SW1: SW_DIP_x08; SW_DIP_SPSTx08_Piano_10.8x21.88mm_W7.62mm_P2.54mm
SW2: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx83-2LFS
SW3: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: EP1C12Q240C8N; QFP50P3460X3460X410-240N
U2: AMS1117-1.5; SOT-223-3_TabPin2
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: NC7WZU04P6X; SOT65P210X110-6N
U5: MT48LC16M16A2TG; TSOP-II-54_22.2x10.16mm_P0.8mm
U6: M51953BFP; SO08
U7: CH559T; SSOP-20_5.3x7.2mm_P0.65mm
U8: EPCS4; SO08
Y1: 21.47727 MHz; Crystal_HC49-U_Vertical
kibuzzard-65D4E5DB: G***; kibuzzard-65D4E5DB

Connections:
+1V5: C4.1, C5.1, C20.2, C21.2, C22.2, C23.2, R3.2, R7.2, U1.72 (VCCINT), U1.81 (VCCINT_5), U1.90 (VCCINT), U1.97 (VCCINT_2), U1.103 (VCCINT_4), U1.110 (VCCINT_3), U1.191 (VCCINT_2), U1.198 (VCCINT_3), U1.204 (VCCINT_4), U1.211 (VCCINT_5), U1.220 (VCCINT_6), U1.229 (VCCINT), U2.2 (VO)
+3.3V: C7.1, C8.1, C9.1, C11.1, C12.2, C15.1, C16.2, C17.2, C18.2, C19.2, C33.1, J2.4, J2.8, J4.4 (VDD), J8.4, J17.1, R1.1, R2.1, RN12.1 (R1.1), RN12.2 (R2.1), RN12.3 (R3.1), RN24.1 (R1.1), RN24.2 (R2.1), RN24.3 (R3.1), RN24.4 (R4.1), RN25.6 (R3.2), RN25.7 (R2.2), RN25.8 (R1.2), RN26.5 (R4.2), RN26.6 (R3.2), RN26.7 (R2.2), RN26.8 (R1.2), RN35.6 (R3.2), RN35.7 (R2.2), RN35.8 (R1.2), RN44.5 (R4.2), RN44.6 (R3.2), RN44.7 (R2.2), RN44.8 (R1.2), U1.9 (VCCIO1), U1.22 (VCCIO1_2), U1.51 (VCCIO1_3), U1.70 (VCCIO4), U1.92 (VCCIO4_2), U1.112 (VCCIO4), U1.130 (VCCIO3_2), U1.148 (TMS), U1.155 (TDI), U1.157 (VCCIO3), U1.172 (VCCIO3), U1.189 (VCCIO2), U1.209 (VCCIO2_2), U1.231 (VCCIO2_3), U3.2 (VO), U4.5 (VCC), U5.1 (VDD), U5.3 (VDDQ), U5.9 (VDDQ), U5.14 (VDD), U5.27 (VDD), U5.43 (VDDQ), U5.49 (VDDQ), U7.20 (VDD33), U8.3 (VCC@3), U8.7 (VCC@7), U8.8 (VCC@8)
+5V: C1.1, C2.1, C6.1, C24.1, C34.1, C35.1, J1.5, J5.2, J6.1 (VBUS), J7.4, J10.5, J13.45, J13.47, J14.9, J15.5, J16.45, J16.47, R12.1, R13.1, R14.1, U2.3 (VI), U3.3 (VI), U6.7 (VCC), U7.19 (VIN5)
+12V: J1.3, J13.48, J16.48
-12V: J1.1, J13.50, J16.50
/A0: J13.28, J16.28, RN2.2 (R2.1)
/A1: J13.27, J16.27, RN2.1 (R1.1)
/A2: J13.30, J16.30, RN2.4 (R4.1)
/A3: J13.29, J16.29, RN2.3 (R3.1)
/A4: J13.32, J16.32, RN3.2 (R2.1)
/A5: J13.31, J16.31, RN3.1 (R1.1)
/A6: J13.22, J16.22, RN6.4 (R4.1)
/A7: J13.21, J16.21, RN6.3 (R3.1)
/A8: J13.24, J16.24, RN1.2 (R2.1)
/A9: J13.17, J16.17, RN11.1 (R1.1)
/A10: J13.20, J16.20, RN11.4 (R4.1)
/A11: J13.19, J16.19, RN11.3 (R3.1)
/A12: J13.23, J16.23, RN1.1 (R1.1)
/A13: J13.26, J16.26, RN1.4 (R4.1)
/A14: J13.25, J16.25, RN1.3 (R3.1)
/A15: J13.18, J16.18, RN11.2 (R2.1)
/AS_CK: J8.1, U1.36 (DCLK), U8.6 (DCLK)
/AS_CS: J8.8, U1.24 (IO_22), U8.1 (NCS)
/AS_DI: J8.7, U1.25 (DATA0), U8.2 (DATA)
/AS_DO: J8.9, U1.37 (IO_23), U8.5 (ASDI)
/BDIR: J13.10, J16.10, RN9.3 (R3.1)
/CLK21M: R9.2, U1.28 (CLK0)
/CLOCK: J13.42, J16.42, RN6.2 (R2.1)
/CS1: J13.1, J16.1, RN7.2 (R2.1)
/CS2: J13.2, J16.2, RN7.3 (R3.1)
/CS12: J13.3, J16.3, RN7.4 (R4.1)
/C_CE: J8.6, RN12.5 (R4.2), U1.33 (NCE)
/C_CONF: J8.5, RN12.7 (R2.2), U1.26 (NCONFIG)
/C_DONE: J8.3, RN12.8 (R1.2), U1.145 (CONF_DONE)
/C_STAT: RN12.6 (R3.2), U1.146 (NSTATUS)
/D0: J13.34, J16.34, RN3.4 (R4.1)
/D1: J13.33, J16.33, RN3.3 (R3.1)
/D2: J13.36, J16.36, RN4.2 (R2.1)
/D3: J13.35, J16.35, RN4.1 (R1.1)
/D4: J13.38, J16.38, RN4.4 (R4.1)
/D5: J13.37, J16.37, RN4.3 (R3.1)
/D6: J13.40, J16.40, RN5.2 (R2.1)
/D7: J13.39, J16.39, RN5.1 (R1.1)
/DIP1: RN19.1 (R1.1), SW1.16
/DIP2: RN19.2 (R2.1), SW1.15
/DIP3: RN19.3 (R3.1), SW1.14
/DIP4: RN19.4 (R4.1), SW1.13
/DIP5: RN20.1 (R1.1), SW1.12
/DIP6: RN20.2 (R2.1), SW1.11
/DIP7: RN20.3 (R3.1), SW1.10
/DIP8: RN20.4 (R4.1), SW1.9
/EXTCLK: R8.2, U1.29 (CLK1)
/HSYNC: J14.13, RN23.3 (R3.1)
/INT: J13.8, J16.8, RN9.1 (R1.1)
/IO0: J15.1, RN13.1 (R1.1), RN44.1 (R1.1)
/IO1: J15.6, RN13.2 (R2.1), RN44.2 (R2.1)
/IO2: J15.2, RN13.3 (R3.1), RN44.3 (R3.1)
/IO3: J15.7, RN13.4 (R4.1), RN44.4 (R4.1)
/IO4: J15.3, RN14.1 (R1.1), RN35.1 (R1.1)
/IO5: J15.8, RN14.2 (R2.1), RN35.2 (R2.1)
/IO6: J15.4, RN14.3 (R3.1), RN35.3 (R3.1)
/IO7: J10.1, RN14.4 (R4.1), RN26.1 (R1.1)
/IO8: J10.6, RN15.1 (R1.1), RN26.2 (R2.1)
/IO9: J10.2, RN15.2 (R2.1), RN26.3 (R3.1)
/IO10: J10.7, RN15.3 (R3.1), RN26.4 (R4.1)
/IO11: J10.3, RN15.4 (R4.1), RN25.1 (R1.1)
/IO12: J10.8, RN16.1 (R1.1), RN25.2 (R2.1)
/IO13: J10.4, RN16.2 (R2.1), RN25.3 (R3.1)
/IORQ: J13.11, J16.11, RN9.4 (R4.1)
/KCLK: J7.5, R14.2, RN22.4 (R4.1), U7.5 (P1.7/SCK)
/KDAT: J7.1, R13.2, RN22.3 (R3.1), U7.2 (P1.4/CS)
/LED1: D1.2 (A), RN17.1 (R1.1)
/LED2: D2.2 (A), RN17.2 (R2.1)
/LED3: D3.2 (A), RN17.3 (R3.1)
/LED4: D4.2 (A), RN17.4 (R4.1)
/LED5: D5.2 (A), RN18.1 (R1.1)
/LED6: D6.2 (A), RN18.2 (R2.1)
/LED7: D7.2 (A), RN18.3 (R3.1)
/LED8: D8.2 (A), RN18.4 (R4.1)
/M1: J13.9, J16.9, RN9.2 (R2.1)
/MA0: U1.203 (IO_36), U5.23 (A0)
/MA1: U1.206 (IO_37), U5.24 (A1)
/MA2: U1.207 (IO_38), U5.25 (A2)
/MA3: U1.208 (IO_39), U5.26 (A3)
/MA4: U1.235 (IO_56), U5.29 (A4)
/MA5: U1.234 (IO_55), U5.30 (A5)
/MA6: U1.233 (IO_54), U5.31 (A6)
/MA7: U1.228 (IO_53), U5.32 (A7)
/MA8: U1.227 (IO_52), U5.33 (A8)
/MA9: U1.226 (IO_51), U5.34 (A9)
/MA10: U1.202 (IO_35), U5.22 (A10)
/MA11: U1.225 (IO_50), U5.35 (A11)
/MA12: U1.224 (IO_49), U5.36 (A12)
/MBA0: U1.200 (IO_33), U5.20 (BA0)
/MBA1: U1.201 (IO_34), U5.21 (BA1)
/MCAS: U1.195 (IO_30), U5.17 (~CAS)
/MCKE: U1.39 (IO_25), U5.37 (CKE)
/MCLK: R10.1, U5.38 (CLK)
/MCS: U1.197 (IO_32), U5.19 (~CS)
/MD0: U1.181 (IO_20), U5.2 (DQ0)
/MD1: U1.182 (IO_21), U5.4 (DQ1)
/MD2: U1.183 (IO_22), U5.5 (DQ2)
/MD3: U1.184 (IO_23), U5.7 (DQ3)
/MD4: U1.185 (IO_24), U5.8 (DQ4)
/MD5: U1.186 (IO_25), U5.10 (DQ5)
/MD6: U1.187 (IO_26), U5.11 (DQ6)
/MD7: U1.188 (IO_27), U5.13 (DQ7)
/MD8: U1.222 (IO_47), U5.42 (DQ8)
/MD9: U1.219 (IO_46), U5.44 (DQ9)
/MD10: U1.218 (IO_45), U5.45 (DQ10)
/MD11: U1.217 (IO_44), U5.47 (DQ11)
/MD12: U1.216 (IO_43), U5.48 (DQ12)
/MD13: U1.215 (IO_42), U5.50 (DQ13)
/MD14: U1.214 (IO_41), U5.51 (DQ14)
/MD15: U1.213 (IO_40), U5.53 (DQ15)
/MERQ: J13.12, J16.12, RN10.1 (R1.1)
/MLDQ: U1.193 (IO_28), U5.15 (DQML)
/MRAS: U1.196 (IO_31), U5.18 (~RAS)
/MUDQ: U1.223 (IO_48), U5.39 (DQMH)
/MWE: U1.194 (IO_29), U5.16 (~WE)
/PWRLED: R5.1, U1.240 (IO)
/RD: J13.14, J16.14, RN10.3 (R3.1)
/RESET: J13.15, J16.15, RN6.1 (R1.1), RN24.8 (R1.2), U6.6 (OUT)
/RFSH: J13.6, J16.6, RN8.3 (R3.1), RN24.5 (R4.2)
/RSV5: J13.5, J16.5, RN8.2 (R2.1), RN24.7 (R2.2)
/RSV16: J13.16, J16.16, RN10.4 (R4.1), RN24.6 (R3.2)
/SCLK: J14.12, RN23.4 (R4.1)
/SDAT: J14.15, RN23.1 (R1.1)
/SD_CK: J4.5 (CLK), R2.2, RN21.3 (R3.1)
/SD_CM: J4.3 (CMD), R1.2, RN21.4 (R4.1)
/SD_D0: J4.7 (DAT0), RN21.2 (R2.1)
/SD_D1: J4.8 (DAT1), RN21.1 (R1.1)
/SD_D2: J4.1 (DAT2), RN22.2 (R2.1)
/SD_D3: J4.2 (DAT3/CD), RN22.1 (R1.1)
/SL0: RN29.4 (R4.1), U1.105 (IO_17)
/SL1: RN29.3 (R3.1), U1.106 (IO_18)
/SL2: RN29.2 (R2.1), U1.107 (IO_19)
/SL3: RN29.1 (R1.1), U1.108 (IO_20)
/SL4: RN28.4 (R4.1), U1.113 (IO_21)
/SL5: RN28.3 (R3.1), U1.114 (IO_22)
/SLTSL1: J16.4, RN8.1 (R1.1)
/SLTSL2: J13.4, RN7.1 (R1.1)
/SOUND_L: C26.2, C27.2, C29.2, J11.T
/SOUND_R: C28.2, J11.S
/SR0: RN28.2 (R2.1), U1.115 (IO_23)
/SR1: RN28.1 (R1.1), U1.116 (IO_24)
/SR2: RN27.4 (R4.1), U1.117 (IO_25)
/SR3: RN27.3 (R3.1), U1.118 (IO_26)
/SR4: RN27.2 (R2.1), U1.119 (IO_27)
/SR5: RN27.1 (R1.1), U1.120 (IO_28)
/SW1: J13.44, J16.44, RN5.3 (R3.1)
/SW2: J13.46, J16.46, RN5.4 (R4.1)
/USBN1: J2.7, U1.236 (IO_57)
/USBP1: J2.2, U1.237 (IO_58)
/VB0: RN31.2 (R2.1), U1.77 (IO_56)
/VB1: RN31.1 (R1.1), U1.78 (IO_57)
/VB2: RN30.4 (R4.1), U1.79 (IO)
/VB3: RN30.3 (R3.1), U1.82 (IO_2)
/VB4: RN30.2 (R2.1), U1.83 (IO_3)
/VB5: RN30.1 (R1.1), U1.84 (IO_4)
/VB_CV: C30.2, J14.3
/VG0: RN32.4 (R4.1), U1.85 (IO_5)
/VG1: RN32.3 (R3.1), U1.86 (IO_6)
/VG2: RN32.2 (R2.1), U1.87 (IO_7)
/VG3: RN32.1 (R1.1), U1.88 (IO_8)
/VG4: RN31.4 (R4.1), U1.93 (IO_9)
/VG5: RN31.3 (R3.1), U1.94 (IO_10)
/VG_SY: C31.2, J14.2, J18.3
/VR0: RN34.2 (R2.1), U1.95 (IO_11)
/VR1: RN34.1 (R1.1), U1.98 (IO_12)
/VR2: RN33.4 (R4.1), U1.99 (IO_13)
/VR3: RN33.3 (R3.1), U1.100 (IO_14)
/VR4: RN33.2 (R2.1), U1.101 (IO_15)
/VR5: RN33.1 (R1.1), U1.104 (IO_16)
/VR_SC: C32.2, J14.1, J18.4
/VSYNC: J14.14, RN23.2 (R2.1)
/WAIT: J13.7, J16.7, RN8.4 (R4.1)
/WR: J13.13, J16.13, RN10.2 (R2.1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.2, C25.2, C33.2, C34.2, C35.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), J1.2, J1.4, J2.1, J3.2, J4.6 (VSS), J6.4 (GND), J6.5 (Shield), J7.3, J8.2, J8.10, J10.9, J11.G, J13.41, J13.43, J14.5, J14.6, J14.7, J14.8, J14.10, J15.9, J16.41, J16.43, J18.1, J18.2, J18.S1 (SHIELD), J18.S2 (SHIELD), J18.S3 (SHIELD), RN12.4 (R4.1), RN37.7 (R2.2), RN38.5 (R4.2), RN40.7 (R2.2), RN41.5 (R4.2), RN43.7 (R2.2), SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, SW2.1, SW3.1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
unnamed: D9.2 (A), R5.2
unnamed: D10.2 (A), R12.2
unnamed: D10.1 (K), U7.11 (PWM2/P2.5)
unnamed: F1.1, J3.1
unnamed: F1.2, J5.1
unnamed: J6.3 (D+), U7.14 (D+/P5.1)
unnamed: J6.2 (D-), U7.15 (D-/P5.0)
unnamed: C26.1, J13.49
unnamed: C27.1, J16.49
unnamed: J2.6, J17.2
unnamed: RN1.8 (R1.2), U1.159 (IO_52)
unnamed: RN1.7 (R2.2), U1.160 (IO)
unnamed: RN1.6 (R3.2), U1.161 (IO_2)
unnamed: RN1.5 (R4.2), U1.162 (IO_3)
unnamed: RN2.8 (R1.2), U1.163 (IO_4)
unnamed: RN2.7 (R2.2), U1.164 (IO_5)
unnamed: RN2.6 (R3.2), U1.165 (IO_6)
unnamed: RN2.5 (R4.2), U1.166 (IO_7)
unnamed: RN3.8 (R1.2), U1.167 (IO_8)
unnamed: RN3.7 (R2.2), U1.168 (IO_9)
unnamed: RN3.6 (R3.2), U1.169 (IO_10)
unnamed: RN3.5 (R4.2), U1.170 (IO_11)
unnamed: RN4.8 (R1.2), U1.173 (IO_12)
unnamed: RN4.7 (R2.2), U1.174 (IO_13)
unnamed: RN4.6 (R3.2), U1.175 (IO_14)
unnamed: RN4.5 (R4.2), U1.176 (IO_15)
unnamed: RN5.8 (R1.2), U1.177 (IO_16)
unnamed: RN5.7 (R2.2), U1.178 (IO_17)
unnamed: RN5.6 (R3.2), U1.179 (IO_18)
unnamed: RN5.5 (R4.2), U1.180 (IO_19)
unnamed: RN6.8 (R1.2), U1.153 (CLK2)
unnamed: RN6.7 (R2.2), U1.144 (IO_49), U1.152 (CLK3)
unnamed: RN6.6 (R3.2), U1.156 (IO_50)
unnamed: RN6.5 (R4.2), U1.158 (IO_51)
unnamed: RN7.8 (R1.2), U1.121 (IO_29)
unnamed: RN7.7 (R2.2), U1.122 (IO_30)
unnamed: RN7.6 (R3.2), U1.123 (IO_31)
unnamed: RN7.5 (R4.2), U1.124 (IO_32)
unnamed: RN8.8 (R1.2), U1.125 (IO_33)
unnamed: RN8.7 (R2.2), U1.126 (IO_34)
unnamed: RN8.6 (R3.2), U1.127 (IO_35)
unnamed: RN8.5 (R4.2), U1.128 (IO_36)
unnamed: RN9.8 (R1.2), U1.131 (IO_37)
unnamed: RN9.7 (R2.2), U1.132 (IO_38)
unnamed: RN9.6 (R3.2), U1.133 (IO_39)
unnamed: RN9.5 (R4.2), U1.134 (IO_40)
unnamed: RN10.8 (R1.2), U1.135 (IO_41)
unnamed: RN10.7 (R2.2), U1.136 (IO_42)
unnamed: RN10.6 (R3.2), U1.137 (IO_43)
unnamed: RN10.5 (R4.2), U1.138 (IO_44)
unnamed: RN11.8 (R1.2), U1.139 (IO_45)
unnamed: RN11.7 (R2.2), U1.140 (IO_46)
unnamed: RN11.6 (R3.2), U1.141 (IO_47)
unnamed: RN11.5 (R4.2), U1.143 (IO_48)
unnamed: RN13.8 (R1.2), U1.1 (IO_2)
unnamed: RN13.7 (R2.2), U1.2 (IO_3)
unnamed: RN13.6 (R3.2), U1.3 (IO_4)
unnamed: RN13.5 (R4.2), U1.4 (IO_5)
unnamed: RN14.8 (R1.2), U1.5 (IO_6)
unnamed: RN14.7 (R2.2), U1.6 (IO_7)
unnamed: RN14.6 (R3.2), U1.7 (IO_8)
unnamed: RN14.5 (R4.2), U1.8 (IO_9)
unnamed: RN15.8 (R1.2), U1.11 (IO_10)
unnamed: RN15.7 (R2.2), U1.12 (IO_11)
unnamed: RN15.6 (R3.2), U1.13 (IO_12)
unnamed: RN15.5 (R4.2), U1.14 (IO_13)
unnamed: RN16.8 (R1.2), U1.15 (IO_14)
unnamed: RN16.7 (R2.2), U1.16 (IO_15)
unnamed: RN17.8 (R1.2), U1.43 (IO_28)
unnamed: RN17.7 (R2.2), U1.44 (IO_29)
unnamed: RN17.6 (R3.2), U1.45 (IO_30)
unnamed: RN17.5 (R4.2), U1.46 (IO_31)
unnamed: RN18.8 (R1.2), U1.47 (IO_32)
unnamed: RN18.7 (R2.2), U1.48 (IO_33)
unnamed: RN18.6 (R3.2), U1.49 (IO_34)
unnamed: RN18.5 (R4.2), U1.50 (IO_35)
unnamed: RN19.8 (R1.2), U1.53 (IO_36)
unnamed: RN19.7 (R2.2), U1.54 (IO_37)
unnamed: RN19.6 (R3.2), U1.55 (IO_38)
unnamed: RN19.5 (R4.2), U1.56 (IO_39)
unnamed: RN20.8 (R1.2), U1.57 (IO_40)
unnamed: RN20.7 (R2.2), U1.58 (IO_41)
unnamed: RN20.6 (R3.2), U1.59 (IO_42)
unnamed: RN20.5 (R4.2), U1.60 (IO_43)
unnamed: RN21.8 (R1.2), U1.61 (IO_44)
unnamed: RN21.7 (R2.2), U1.62 (IO_45)
unnamed: RN21.6 (R3.2), U1.63 (IO_46)
unnamed: RN21.5 (R4.2), U1.64 (IO_47)
unnamed: RN22.8 (R1.2), U1.65 (IO_48)
unnamed: RN22.7 (R2.2), U1.66 (IO_49)
unnamed: RN22.6 (R3.2), U1.67 (IO_50)
unnamed: RN22.5 (R4.2), U1.68 (IO_51)
unnamed: RN23.8 (R1.2), U1.73 (IO_52)
unnamed: RN23.7 (R2.2), U1.74 (IO_53)
unnamed: RN23.6 (R3.2), U1.75 (IO_54)
unnamed: RN23.5 (R4.2), U1.76 (IO_55)
unnamed: C28.1, RN27.8 (R1.2), RN36.1 (R1.1)
unnamed: RN27.7 (R2.2), RN36.2 (R2.1), RN36.8 (R1.2)
unnamed: RN27.6 (R3.2), RN36.3 (R3.1), RN36.7 (R2.2)
unnamed: RN27.5 (R4.2), RN36.4 (R4.1), RN36.6 (R3.2)
unnamed: RN28.8 (R1.2), RN36.5 (R4.2), RN37.1 (R1.1)
unnamed: RN28.7 (R2.2), RN37.2 (R2.1), RN37.8 (R1.2)
unnamed: C29.1, RN28.6 (R3.2), RN37.3 (R3.1)
unnamed: RN28.5 (R4.2), RN37.4 (R4.1), RN37.6 (R3.2)
unnamed: RN29.8 (R1.2), RN37.5 (R4.2), RN38.1 (R1.1)
unnamed: RN29.7 (R2.2), RN38.2 (R2.1), RN38.8 (R1.2)
unnamed: RN29.6 (R3.2), RN38.3 (R3.1), RN38.7 (R2.2)
unnamed: RN29.5 (R4.2), RN38.4 (R4.1), RN38.6 (R3.2)
unnamed: C30.1, RN30.8 (R1.2), RN39.1 (R1.1)
unnamed: RN30.7 (R2.2), RN39.2 (R2.1), RN39.8 (R1.2)
unnamed: RN30.6 (R3.2), RN39.3 (R3.1), RN39.7 (R2.2)
unnamed: RN30.5 (R4.2), RN39.4 (R4.1), RN39.6 (R3.2)
unnamed: RN31.8 (R1.2), RN39.5 (R4.2), RN40.1 (R1.1)
unnamed: RN31.7 (R2.2), RN40.2 (R2.1), RN40.8 (R1.2)
unnamed: C31.1, RN31.6 (R3.2), RN40.3 (R3.1)
unnamed: RN31.5 (R4.2), RN40.4 (R4.1), RN40.6 (R3.2)
unnamed: RN32.8 (R1.2), RN40.5 (R4.2), RN41.1 (R1.1)
unnamed: RN32.7 (R2.2), RN41.2 (R2.1), RN41.8 (R1.2)
unnamed: RN32.6 (R3.2), RN41.3 (R3.1), RN41.7 (R2.2)
unnamed: RN32.5 (R4.2), RN41.4 (R4.1), RN41.6 (R3.2)
unnamed: C32.1, RN33.8 (R1.2), RN42.1 (R1.1)
unnamed: RN33.7 (R2.2), RN42.2 (R2.1), RN42.8 (R1.2)
unnamed: RN33.6 (R3.2), RN42.3 (R3.1), RN42.7 (R2.2)
unnamed: RN33.5 (R4.2), RN42.4 (R4.1), RN42.6 (R3.2)
unnamed: RN34.8 (R1.2), RN42.5 (R4.2), RN43.1 (R1.1)
unnamed: RN34.7 (R2.2), RN43.2 (R2.1), RN43.8 (R1.2)
unnamed: R10.2, U1.38 (IO_24)
unnamed: C10.1, R7.1, U1.27 (VCCA_PLL1)
unnamed: C3.1, R3.1, U1.154 (VCCA_PLL2)
unnamed: C14.1, R11.1, U4.1 (A1), U4.4 (Y2), Y1.2
unnamed: C13.1, R11.2, U4.3 (A2), Y1.1
unnamed: R8.1, R9.1, U4.6 (Y1)
unnamed: C25.1, SW2.2, U6.5 (DC)
unnamed: SW3.2, U7.9 (P4.6)

## Commit log

2025-03-23 upd2411
2026-06-24 upd2606
2026-06-24 v1.51 UPD2406
    sync https://github.com/cristianoag/trhmsx

Notices in the files:
hardware/trhmsx/trhmsx.kicad_pcb:
Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International License
This work is licensed under a
